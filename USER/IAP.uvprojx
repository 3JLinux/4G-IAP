# Keil uVision project IAP.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IAP +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\IAP;..\HARDWARE\STMFLASH;..\HARDWARE\SIM800A;..\HARDWARE\CRC16;..\GPRS_HANDLE;..\HARDWARE\SIM7600CE;..\HARDWARE\FIFO;..\SYSTEM\printf;..\SYSTEM\printf\xprintf
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/SIM800A/: sim800a.c
    ../HARDWARE/CRC16/: crc16.c
    ../HARDWARE/SIM7600CE/: sim7600ce.c sim7600ce_connect.c
    ../HARDWARE/FIFO/: fifo.c
  group GPRS_HANDLE
    ../GPRS_HANDLE/: gprs_handle.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/printf/: sysprintf.c
    ../SYSTEM/printf/xprintf/: xprintf.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c
  group IAP
    ../IAP/: iap.c
